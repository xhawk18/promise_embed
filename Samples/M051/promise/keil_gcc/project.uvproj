# Keil uVision project project.uvproj, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: project
  AfterMake: "c:\Program Files (x86)\GNU Tools ARM Embedded\5.4 2016q3\bin\arm-none-eabi-objcopy.exe" -S -O ihex "@L.elf" "@L.hex"
  AfterMake: "@KARM\ARMCC\bin\fromelf" --text -c "@L.elf" -z --output "@L.txt"
  group CMSIS
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: M051Series.h system_M051Series.h system_M051Series.c
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/gcc/: printf.c startup_M051Series.c syscalls.c
  group Driver
    ../../../../M051SeriesBSP/LibM051Series/StdDriver/src/: retarget.c
  group Src
    ../: Main.c promise.cpp
