# Keil uVision project Project.uvprojx, settings and files
target STM32F302x8 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F302RB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: joss_stick
  AfterMake: "c:\Program Files (x86)\GNU Tools ARM Embedded\5.4 2016q3\bin\arm-none-eabi-objcopy.exe" -S -O ihex "@L.elf" "@L.hex"
  AfterMake: "@KARM\ARMCC\bin\fromelf" --text -c "@L.elf" -z --output "@L.txt"
  group compiler_gcc
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/TrueSTUDIO/: startup_stm32f302x8.s
  group STM32F30x_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_fmc.c stm32f30x_rtc.c stm32f30x_flash.c stm32f30x_misc.c stm32f30x_dbgmcu.c stm32f30x_iwdg.c stm32f30x_rcc.c stm32f30x_usart.c stm32f30x_exti.c stm32f30x_wwdg.c stm32f30x_i2c.c stm32f30x_syscfg.c stm32f30x_spi.c stm32f30x_can.c stm32f30x_adc.c stm32f30x_gpio.c stm32f30x_tim.c stm32f30x_crc.c stm32f30x_opamp.c stm32f30x_dma.c stm32f30x_comp.c stm32f30x_pwr.c stm32f30x_dac.c stm32f30x_hrtim.c
  group User
    ../: system_stm32f30x.c main.cpp stm32f30x_it.cpp
software components: CMSIS:CORE 5.0.0
